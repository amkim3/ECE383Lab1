.lib LTC.lib
