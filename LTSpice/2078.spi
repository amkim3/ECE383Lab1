.ac oct 1000 1 10k

.lib LTC.lib
